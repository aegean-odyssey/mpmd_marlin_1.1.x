# Keil uVision project Project.uvprojx, settings and files
target STM32F072B-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B-Discovery +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F072B_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../../../Drivers/BSP/STM32F072B-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c4 size 0x3f3c
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/BSP/STM32F072B-Discovery
    ../../../../../../../../Drivers/BSP/STM32F072B-Discovery/: stm32f072b_discovery.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal_spi.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Example/User
    ../Src/: main.c stm32f0xx_it.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
